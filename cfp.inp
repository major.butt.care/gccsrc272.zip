L_mulsi3
L_udivsi3
L_divsi3
L_umodsi3
L_modsi3
L_lshrsi3
L_ashrsi3
L_ashlsi3
L_divdf3
L_muldf3
L_negdf2
L_adddf3
L_subdf3
L_eqdf2
L_nedf2
L_gtdf2
L_gedf2
L_ltdf2
L_ledf2
L_fixdfsi
L_fixsfsi
L_floatsidf
L_floatsisf
L_addsf3
L_negsf2
L_subsf3
L_eqsf2
L_nesf2
L_gtsf2
L_gesf2
L_ltsf2
L_lesf2
L_mulsf3
L_divsf3
L_truncdfsf2
L_extendsfdf2
